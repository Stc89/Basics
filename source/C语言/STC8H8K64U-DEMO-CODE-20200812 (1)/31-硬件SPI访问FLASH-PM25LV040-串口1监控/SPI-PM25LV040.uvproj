# Keil uVision project SPI-PM25LV040.uvproj, settings and files
target SPI-PM25LV040 (MCS-51)
  device: STC8H1K16 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: SPI-PM25LV040 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: SPI-PM25LV040.c
