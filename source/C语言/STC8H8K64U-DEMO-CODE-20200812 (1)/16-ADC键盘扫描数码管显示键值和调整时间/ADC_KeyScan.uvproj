# Keil uVision project ADC_KeyScan.uvproj, settings and files
target ADC_KeyScan (MCS-51)
  device: STC8H1K16 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: ADC_KeyScan +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: ADC_KeyScan.c
