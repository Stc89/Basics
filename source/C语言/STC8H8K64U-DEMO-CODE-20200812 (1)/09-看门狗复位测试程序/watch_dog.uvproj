# Keil uVision project watch_dog.uvproj, settings and files
target watch_dog (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: watch_dog +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: watch_dog.c
