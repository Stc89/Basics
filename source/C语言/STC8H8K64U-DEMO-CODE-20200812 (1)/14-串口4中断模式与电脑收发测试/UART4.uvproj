# Keil uVision project UART4.uvproj, settings and files
target UART4 (MCS-51)
  device: STC8H1K16 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: UART4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: UART4.c
