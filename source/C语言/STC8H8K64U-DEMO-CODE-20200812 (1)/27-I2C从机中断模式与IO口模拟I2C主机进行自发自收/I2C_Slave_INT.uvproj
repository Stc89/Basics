# Keil uVision project I2C_Slave_INT.uvproj, settings and files
target I2C_Slave_INT (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: I2C_Slave_INT +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: I2C_Slave_INT.c
