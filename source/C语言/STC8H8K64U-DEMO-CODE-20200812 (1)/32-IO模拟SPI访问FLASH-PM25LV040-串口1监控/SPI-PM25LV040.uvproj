# Keil uVision project SPI-PM25LV040.uvproj, settings and files
target SPI-PM25LV040 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: SPI-PM25LV040 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: SPI-PM25LV040.c
