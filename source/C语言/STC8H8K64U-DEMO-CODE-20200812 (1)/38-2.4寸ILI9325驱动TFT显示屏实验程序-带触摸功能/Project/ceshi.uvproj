# Keil uVision project ceshi.uvproj, settings and files
target QD-TFT (MCS-51)
  device: STC8H1K16 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: ceshi +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\font;..\GUI;..\LCD;..\sys;..\touch;..\USER
  group USER
    ../GUI/: gui.c
    ../USER/: main.c test.c
  group SYSTEM
    ../sys/: sys.c STARTUP.A51
  group HARDWARE
    ../LCD/: LCD.c
    ../touch/: touch.c
