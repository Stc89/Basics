# Keil uVision project PownDownSave.uvproj, settings and files
target PownDownSave (MCS-51)
  device: STC8H1K16 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: PownDownSave +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: PownDownSave.c
