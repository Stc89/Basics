# Keil uVision project LCD128x64.uvproj, settings and files
target LCD128x64 (MCS-51)
  device: STC8H1K16 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: LCD128x64 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: LCD128x64.c
