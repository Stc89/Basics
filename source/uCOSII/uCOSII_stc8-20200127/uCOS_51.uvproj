# Keil uVision project uCOS_51.uvproj, settings and files
target uCOS_51 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: uCOS_51 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\uCOS-II\Inc
  group MCS-51
    ./uCOS-II/MCS-51/: STARTUP.A51 OS_CPU_C.C OS_CPU_A.A51
  group uCOS-II
    ./uCOS-II/Src/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C
  group BSP
    ./BSP/: serial.c system.c
  group APP
    ./APP/: main.c
  group Note
    ./Note/: ReadMe.txt
